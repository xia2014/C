# Keil uVision project iSO-STM32.uvproj, settings and files
target SmartCar (ARM-ADS)
  device: STM32F103ZD STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x805FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: SmartCar +hex
  c flags: Optim=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\User;..\User\bsp_exti;..\User\bsp_gpio;..\User\bsp_spi_flash;..\User\bsp_SysTick;..\User\bsp_timer;..\User\bsp_usart;..\Libraries\CMSIS\startup;..\Libraries\FWlib\inc;..\Libraries\CMSIS;..\User\wifi;..\User\ov7725;..\User\lcd
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../Libraries/FWlib/src/: misc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group USER
    ../User/: main.c stm32f10x_conf.h stm32f10x_it.h stm32f10x_it.c
    ../User/bsp_exti/: bsp_exti.c
    ../User/bsp_gpio/: bsp_gpio.c
    ../User/bsp_spi_flash/: bsp_spi_flash.c
    ../User/bsp_SysTick/: bsp_SysTick.c
    ../User/bsp_usart/: bsp_usart.c
    ../User/bsp_timer/: bsp_timer.c
    ../User/wifi/: wifi_config.c wifi_function.c
    ../User/lcd/: bsp_ili9341_lcd.c
    ../User/ov7725/: bsp_ov7725.c bsp_sccb.c
  group DOC
    ../../Doc/: readme.txt
